# Keil uVision project UAV-Interface.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Sample +hex
  AfterMake: D:\Program Files (x86)\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin -o E:/Work/QAII/UAV/Interface/trunk/Output/Sample.bin E:/Work/QAII/UAV/Interface/trunk/Output/Sample.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\ff10;..\..\ff10\option;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\lcd;..\..\User\BSP\led;..\..\User\BSP\sdcard;..\..\User\BSP\spi;..\..\User\BSP\SysTick;..\..\User\BSP\usart;..\..\User\OS;..\..\uCOSIII\uC-CPU;..\..\uCOSIII\uC-LIB;..\..\uCOSIII\uCOS-III\Ports;..\..\uCOSIII\uCOS-III\Source;..\..\Libraries\CMSIS\startup;..\..\User\BSP\mos;..\..\User\BSP\Bero;..\..\User\BSP\pwm;..\..\User\BSP\eeprom;..\..\User\BSP\can
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: includes.h main.c stm32f10x_it.c
  group ff10
    ../../ff10/: diskio.c ff.c
    ../../ff10/option/: ccsbcs.c
  group BSP
    ../../User/BSP/: bsp.c
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/spi/: fatfs_flash_spi.c
    ../../User/BSP/SysTick/: bsp_SysTick.c
    ../../User/BSP/usart/: bsp_usart.c
    ../../User/BSP/mos/: bsp_mos.c
    ../../User/BSP/Bero/: bsp_bero.c
    ../../User/BSP/pwm/: bsp_pwm.c
    ../../User/BSP/eeprom/: eeprom.c
    ../../User/BSP/can/: bsp_can.c
  group APP
    ../../User/APP/: app.c Breathing_app.c Sample_app.c DJI_Battery.c USART_Decode_app.c Sample_app.h
  group uCOS_Ports
    ../../uCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS_Source
    ../../uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS_CPU
    ../../uCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOS_LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOS_CFG
    ../../User/OS/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
